# IAR project 5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NODEBUG
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$MSP432DRIVERLIB$/inc/CMSIS; -I$MSP432DRIVERLIB$/inc; -I$MSP432DRIVERLIB$/driverlib/MSP432P4xx; -D__MSP432P401R__; -Dewarm; -DMSP432WARE; --debug; --silent
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: 5.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_MSP_EXP432P401R.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $MSP432DRIVERLIB$/driverlib/MSP432P4xx/ewarm/msp432p4xx_driverlib.a; --silent; --cpu=Cortex-M4F; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group UART Echo/Configuration files
    ./: 5.cfg
  group UART Echo/Documentation
    ./: README.html
  group UART Echo/Header files
    ./: Board.h MSP_EXP432P401R.h
  group UART Echo/Source files
    ./: 5_MSP_EXP432P401R.icf MSP_EXP432P401R.c uartecho.c
